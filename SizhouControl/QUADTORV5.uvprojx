# Keil uVision project QUADTORV5.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: QUADTORV5 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\EXTERN;.\FWLib\inc;.\HARDWARE\LED;.\HARDWARE\TIMER3;.\HARDWARE\TIMER4;.\SYSTEM\delay;.\SYSTEM\sys;.\USER;.\HARDWARE\WAVEFILT;.\HARDWARE\MPU6050;.\HARDWARE\PID;.\HARDWARE\CONTROL;.\HARDWARE\ultrasonic;.\DT;.\HARDWARE\niming_usart;.\HARDWARE\DEBUG;.\HARDWARE\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group START
    ./: startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
  group COER
    ./CORE/: core_cm3.c
  group FWLIB
    ./FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./HARDWARE/LED/: led.c
    ./HARDWARE/PID/: PID.c
    ./HARDWARE/TIMER3/: timer3.c
    ./HARDWARE/TIMER4/: timer4.c
    ./HARDWARE/WAVEFILT/: WaveFiltering.c
    ./HARDWARE/MPU6050/: mpu6050.c mpu6050iic.c
    ./HARDWARE/CONTROL/: control.c
    ./HARDWARE/ultrasonic/: Timer2_CH1.c ultrasonic.c
    ./DT/: datatranslate.c
    ./HARDWARE/niming_usart/: nimingusart.c
    ./HARDWARE/DEBUG/: debug.c
    ./HARDWARE/OLED/: oled.c
